# Keil uVision project Lcd_ST7735.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Lcd_ST7735 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: st7735_TFT.c
